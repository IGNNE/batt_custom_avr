## Kconfig
```kconfig
menuconfig DRIVERS_BATT_CUSTOM_AVR
	bool "batt_custom_avr"
	default n
	---help---
		Battery voltage via custom AVR MCU
```
